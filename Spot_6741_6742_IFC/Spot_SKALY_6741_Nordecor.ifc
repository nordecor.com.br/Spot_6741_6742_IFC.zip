Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-04-16T14:59:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 16 14:59:47 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\849e205b-5d7c-4348-ab1d-736b2a442288\fe0beb1d-d477-4f15-aacd-03bbb7b56ae6\ifc * Database version: 5507 * Database creation date: Wed Apr 16 14:59:47 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 16 14:59:47 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 16 14:59:47 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6741, Spot_SKALY_6741_6742_Nordecor_IFC:6741:329892
In: Nível 1
Type - Material: Plástico - PC - Transparente, LED, Metal - Alumínio - Branco
Type - Cotas - Comprimento conector: 165 mm; Comprimento do Spot: 130 mm; Diâmetro do Spot: 30 mm
Type - Dados - Data de atualização: 16/04/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Spot LED acabamento branco para trilho SKALY tip dupla ação 9W 2700K 24º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú/SC - Brasil; Modelo: 6741; Nome do tipo: 6741; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6741.png; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-para-trilho-skaly-7w-2-700k/
Type - Elétrico - Comentários de voltagem: DC48V - 2 Seções; Lâmpada: LED
Type - Fotométricos - Ângulo de abertura: 24 deg; Fluxo luminoso: 297 lm; IRC: 97; Potência: 9 W; Temperatura de cor: 2700 K
Type - Gráficos - Simbologia: Imagem raster: 6741 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - PC - Transparente; Spot: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Spot_SKALY_6741_6742_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; Fonte luminosa: yes
Cotas - Ângulo de rotação: 0 deg; Área: 0.0171255 m2; Inclinação do Spot: 63 deg; Volume: 0.0000477831 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Ângulo de inclinação: 63 deg; Família: Spot_SKALY_6741_6742_Nordecor_IFC: 6741; Família e tipo: Spot_SKALY_6741_6742_Nordecor_IFC: 6741; ID de tipo: Spot_SKALY_6741_6742_Nordecor_IFC: 6741; Tipo: Spot_SKALY_6741_6742_Nordecor_IFC: 6741
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
